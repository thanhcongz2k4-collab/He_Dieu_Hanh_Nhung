## Tuan4/Config.in
```kconfig
config BR2_PACKAGE_HELLO_G2
    bool "hello-G2"
    help
      Goi ung dung hello-G2 cua nhom S2.
```
